# Keil uVision project dm_h7_demo.uvprojx, settings and files
target dm_h7_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: dm_h7_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../deivce;../algorithm;../Bsp;../matrix_tool;../deivce/DamiaoMotors;../deivce/GM6020;../deivce/LKmotors;../deivce/WS2812/inc;../deivce/serial_plot;../deivce/referee_system;../deivce/RC_remote;../deivce/M3508;../deivce/M2006;../deivce/BMI088/inc;../application;../deivce/video_decode;../deivce/minipc;../deivce/UI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group bsp
    ../Bsp/: bsp_dwt.c bsp_fdcan.c bsp_uart.c
  group algorithim
    ../algorithm/: CRC8_CRC16.c kalman_filter.c kf_imu.c pid.c scara_kinematics.c
  group matrix_tool
    ../matrix_tool/: user_mat.c
  group imu
    ../deivce/: N100imu.c
    ../deivce/BMI088/: BMI088driver.c BMI088Middleware.c
  group motor
    ../deivce/M3508/: M3508motors.c
    ../deivce/DamiaoMotors/: DamiaoMotors.c
    ../deivce/M2006/: M2006motors.c
  group remote
    ../deivce/RC_remote/: RC_protocol.c
    ../deivce/: new_remote.c
  group referee
    ../deivce/referee_system/: referee.c
  group serial_plot
    ../deivce/serial_plot/: serialplot.c
  group application
    ../application/: arm.c chassis.c robot_def.h robot_cmd.c UI_task.c sucker.c video.c
  group video_decode
    ../deivce/video_decode/: video_decode.c
  group minipc
    ../deivce/minipc/: minipc_protocol.c
  group cm_device
    ../deivce/: cm_device.c
  group UI_real
    ../deivce/UI/: ui_g.c ui_interface.c
software components: CMSIS:CORE 4.3.0
